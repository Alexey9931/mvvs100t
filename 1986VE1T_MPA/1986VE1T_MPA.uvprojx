# Keil uVision project 1986VE1T_MPA.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MDR32F1QI Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: 1986VE1T_MPA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  scatter file: .\Objects\1986VE1T_MPA.sct
  group Source Group 1
    ./: ADC.c ADC.h CLOCK.c CLOCK.h DMA.c DMA.h main.c main.h MDR32_Drivers.h PORTS.c PORTS.h rs422_protocol.c rs422_protocol.h TIMER.c TIMER.h UART.c UART.h EBC.c EBC.h MT-12864Av6.c MT-12864Av6.h SystemFont5x7R.c SystemFont5x7R.h external_ram.c external_ram.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.2i, Drivers:ADC 2.0.2i, Drivers:BKP 2.0.2i, Drivers:DMA 2.0.2i, Drivers:EBC 2.0.2i, Drivers:EEPROM 2.0.2i, Drivers:PORT 2.0.2i, Drivers:RST_CLK 2.0.2i, Drivers:SSP 2.0.2i, Drivers:TIMER 2.0.2i, Drivers:UART 2.0.2i
